<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\lab4\lab4_new.ewp</path>
  </project>
  <batchBuild/>
</workspace>


